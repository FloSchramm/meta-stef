require xbmc.inc
# SRCREV="9bffa6ce6bfd1b075b14f57c2f7855cc4a45541c"
# SRCREV="8346b7001cafe08aa2fe979eb78723ce5d02b781"
# SRCREV="abf013a59d5101e8d21d89ed3be04d31a894af40"
SRCREV="38110c515cca46399bf57d9a07d1b9a12eef79bd"

PR = "${INC_PR}.2"
